# Repository AxelGunnarson/MyKicad (continued)

## KiCad design Projects/LED_DRIVER_with_fan_IS31LT3117/LED_Driver_ISSI_ALU_IS31LT3117.kicad_pcb (continued)

Board: 2 copper layers, 170.0 x 170.0 mm, 83 parts (0 on the bottom side), 70 nets.

## KiCad design Projects/Stop_light/stop_light.kicad_pcb

Parts:
C1, C4, C7: 22uF; CP_Elec_6.3x5.4; Manufacturer_Part_Number 865080643008
C2, C5, C8: 0.1uF; C_0603_1608Metric; Manufacturer_Part_Number C0603C104K5RECAUTO
C3, C6, C9: 1uF; C_1206_3216Metric; Manufacturer_Part_Number C1206C105K5RACAUTO
D1, D2, D18: PMEG4010EGWX; SOD3616X130N; Mouser Part Number 841-PMEG4010EGWX
D3: LED; DMLQ31_23; Manufacturer_Part_Number DMLQ31.23-HYKY-26-J3T3
D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17: LED; DMLQ31_23
J1: 109159003101916; Mouser Part Number 581-109159003101916
L1, L2, L3: 47uH; SRN6045
R1, R3, R5: 0.3; R_1206_3216Metric
R2, R4, R8: 100; R_1206_3216Metric
U1, U2, U3: IS31LT3360; SOT-89-5; Manufacturer_Part_Number IS31LT3360-SDLS4-TR; Mouser Part Number 870-I31LT3360SDLS4TR

Connections:
/adj: J1.1, R2.2, R4.2, R8.2
GND: C1.2, C2.2, C4.2, C5.2, C7.2, C8.2, J1.2, U1.2 (GND), U2.2 (GND), U3.2 (GND)
unnamed: C3.1, D3.2 (A), R1.1, U1.4 (ISENSE)
unnamed: C3.2, D7.1 (K), L1.2
unnamed: C6.1, D8.2 (A), R3.1, U2.4 (ISENSE)
unnamed: C6.2, D12.1 (K), L2.2
unnamed: C9.1, D13.2 (A), R5.1, U3.4 (ISENSE)
unnamed: C9.2, D17.1 (K), L3.2
unnamed: D1.2, L1.1, U1.1 (LX)
unnamed: D2.2, L2.1, U2.1 (LX)
unnamed: D3.1 (K), D4.2 (A)
unnamed: D4.1 (K), D5.2 (A)
unnamed: D5.1 (K), D6.2 (A)
unnamed: D6.1 (K), D7.2 (A)
unnamed: D8.1 (K), D9.2 (A)
unnamed: D10.1 (K), D11.2 (A)
unnamed: D9.1 (K), D10.2 (A)
unnamed: D11.1 (K), D12.2 (A)
unnamed: D13.1 (K), D14.2 (A)
unnamed: D14.1 (K), D15.2 (A)
unnamed: D15.1 (K), D16.2 (A)
unnamed: D16.1 (K), D17.2 (A)
unnamed: D18.2, L3.1, U3.1 (LX)
unnamed: R2.1, U2.3 (ADJ)
unnamed: R4.1, U3.3 (ADJ)
unnamed: R8.1, U1.3 (ADJ)
VCC: C1.1, C2.1, C4.1, C5.1, C7.1, C8.1, D1.1, D2.1, D18.1, J1.3, R1.2, R3.2, R5.2, U1.5 (VIN), U2.5 (VIN), U3.5 (VIN)

Notes on the sheet:
Iout=0,1/Rs => 0,1/0,3= 330mA

Board: 2 copper layers, 148.2 x 255.8 mm, 40 parts (0 on the bottom side), 27 nets.

## Code that names these connections

File Code/ESP32_GrowLight_plus_Time/ESP32_GrowLight_plus_Time.ino:

#include <WiFi.h>
#include "time.h"
#include <OneWire.h>
#include <DallasTemperature.h>
#include <analogWrite.h>

// Data wire is plugged into pin 3 on the Arduino
#define ONE_WIRE_BUS 3

const char* ssid       = "Olssons iPhonesssd";   //"Mikrofabriken"; // "comhem_1DC167";
const char* password   = "Bermuda100$";    // "hackerspace";  //"CB319A1F42"; 

const char* ntpServer = "pool.ntp.org";
const long  gmtOffset_sec = 3600;
const int   daylightOffset_sec = 3600;

//Output pins setup
int LED_5600K_2 = 18;             // the PWM control pin for 5600K cold white LEDs (18 = LED 1, 15 = LED 2, 2 = LED 3)
int LED_5600K = 2;
int mistMaker = 1;           // the pin for the mistMaker
int fan = 25;                  //fan pin 
int H5V_DC_Pump = 5;           //water pump to pump water from reservoir
int fans = 12;                  //pin for buzzer

//Input pins setup
int NTC_1 = 33  ;    // IO19 is not an analog input, therefore LED 1 cannot be used
int NTC_2 = 32;               
int temp_probe = 3;
int phototransistor = 0; //named LDR in schematic

//int val = 0;  
int NTCvalue = 0;              //NTCvalue is indirectly the temperature of the LED PCB
int NTCvalue2 = 0;              //NTCvalue is indirectly the temperature of the LED PCB
//int fanStatus = 5;            //the status of the highside driver driving the fan
int brightness_5600K = 1;    // initial value for how bright the LED is
int brightness_5600K_daylight = 255;   //Full daylight brightness 0-255
int sensorValue = 0;

int my_hour;                  //figure 0-24 hours used to set when light shall go on/off

long pumpState;       
long onTime = 60000;   // milliseconds of on-time 120000  /pump stays on for 2 minutes
long offTime = 240000; // milliseconds of off-time 10 800 000 = 3 hours
unsigned long previousMillis;  //some global variables available anywhere in the program
unsigned long previousMillis2;
unsigned long currentMillis;
unsigned long currentMillis2;

bool fanState;

// Setup a oneWire instance to communicate with any OneWire devices 
// (not just Maxim/Dallas temperature ICs)
OneWire oneWire(ONE_WIRE_BUS);

// Pass our oneWire reference to Dallas Temperature.
DallasTemperature sensors(&oneWire);

int getHour()
{
  struct tm timeinfo;
  if(!getLocalTime(&timeinfo)){
    Serial.println("Failed to obtain time");
  }

  my_hour = timeinfo.tm_hour;
  return my_hour;
}

void setup()
{
  pinMode(fan, OUTPUT);
  pinMode(NTC_1, INPUT);
  pinMode(NTC_2, INPUT);
  pinMode(H5V_DC_Pump, OUTPUT);
  pinMode(temp_probe, INPUT);
  pinMode(phototransistor, INPUT);

  pumpState = HIGH;
  digitalWrite(H5V_DC_Pump, pumpState);  // Update the actual Pump

  analogWrite(LED_5600K_2, 0);
  
  Serial.begin(115200);

  // Start up the library for 1-wire sensors
  sensors.begin();
  
  //connect to WiFi
  Serial.printf("Connecting to %s ", ssid);
  WiFi.begin(ssid, password);
  while (WiFi.status() != WL_CONNECTED) {
      delay(500);
      Serial.print(".");
  }
  Serial.println(" CONNECTED");
  
  //init and get the time
  configTime(gmtOffset_sec, daylightOffset_sec, ntpServer);
  getHour();

  //disconnect WiFi as it's no longer needed
  WiFi.disconnect(true);
  WiFi.mode(WIFI_OFF);
}

void loop()
{
  brightness();
 // brightnessControl();
    // check to see if it's time to change the state of the Pump
  unsigned long currentMillis = millis();
 
  if((pumpState == HIGH) && (currentMillis - previousMillis >= onTime))
  {
    pumpState = LOW;  // Turn it off
    previousMillis = currentMillis;  // Remember the time
    digitalWrite(H5V_DC_Pump, pumpState);  // Update the actual Pump
  }
  else if ((pumpState == LOW) && (currentMillis - previousMillis >= offTime))
  {
    pumpState = HIGH;  // turn it on  Changed to low to save power 4/3
    previousMillis = currentMillis;   // Remember the time
    digitalWrite(H5V_DC_Pump, pumpState);    // Update the actual Pump
  }

  
  analogWrite(LED_5600K_2, brightness_5600K);
  if (brightness_5600K > 100)   // to ensure that value cant become negative
  {
    analogWrite(LED_5600K, brightness_5600K-99);
  }
  else
  {
    sensorValue = analogRead(phototransistor);
    analogWrite(LED_5600K, brightness_5600K);
    //Serial.println("measure light: ");
    //Serial.println(sensorValue);
    
  }
  
  delay(1000);
}
 
int brightness(){
  NTCvalue = analogRead(NTC_1);
  NTCvalue2 = analogRead(NTC_2);
  //Serial.println(NTCvalue);
  Serial.println("pelle");
  Serial.println(NTCvalue);
  

  
  int setTemp = 3000;  //3000 is ~65 deg C and is considered max allowed temperature.
  if (NTCvalue > setTemp)
    {
      brightness_5600K = 15;
      return brightness_5600K;
      digitalWrite(fan, HIGH);
      Serial.println("Throttling down to 15");
    }
  else if ((NTCvalue < (setTemp - 40)) && (NTCvalue > 50))  //2500 in NTC value is ~40 deg C, 2640 is 50 deg C and is normal working temp on max power with fan ON
    {
     int flowerHour = getHour();
     Serial.println(flowerHour);
     Serial.println("NTCvalue is less than"); 
     Serial.println(setTemp);    
     
    if (flowerHour >= 6 && flowerHour <= 7)
    {
      Serial.print("brightness is: ");
      Serial.println(brightness_5600K);  
      brightness_5600K = 40;
      digitalWrite(fan, HIGH);
      return brightness_5600K;
    }
    else if (flowerHour > 7 && flowerHour <= 18)
    {
      Serial.print("brightness is: ");
      Serial.println(brightness_5600K);  
      brightness_5600K = 250;
      digitalWrite(fan, HIGH);
      return brightness_5600K; 
    }
    else if (flowerHour >= 19 && flowerHour <= 20)
    {
      Serial.print("19-20 brightness is: ");  
      brightness_5600K = 90;
      Serial.println(brightness_5600K);
      digitalWrite(fan, HIGH);
      return brightness_5600K;
    }
    else if (flowerHour >= 21 && flowerHour <= 24)
    {
      digitalWrite(fan, LOW);
      Serial.print("21 - 22 brightness is: ");  
      brightness_5600K = 0;
      Serial.println(brightness_5600K);
      return brightness_5600K;
    }
    else if (flowerHour >= 0 && flowerHour <= 5)
    {
      Serial.print("brightness is: ");  
      brightness_5600K = 0;
      digitalWrite(fan, LOW);
      Serial.println(brightness_5600K);
      return brightness_5600K;
    }
  else if (NTCvalue < 50)
  {
    Serial.println("connection with NTC is broken");
    Serial.print("brightness is: ");
    Serial.println(brightness_5600K);  
    brightness_5600K = 16;
    return brightness_5600K;
  }
}
 
}

## Commit log

2019-05-28 adding file plelel
2019-05-28 added readme file
2019-05-28 added module for LED part
2019-05-28 added step files
2019-05-28 added folder structure and some modules
2019-05-28 moved folders
2019-05-28 sorting out stuff from earlier commit
2019-05-28 just resaved
2019-05-28 added Samac libraries
2019-05-28 added step files related to Heimdall
2019-05-28 new kicad_mod files added
2019-05-28 minor edits to kicad_pcb file
2019-05-29 added samacsys...
2019-06-04 updated with new connector and capacitors
2019-06-08 control board
2019-06-08 added LED with fan project
2019-06-13 stop light updated
2019-06-24 added fabrication files for stop light
2019-07-07 added pca96...
2019-08-18 updates to Control board and LED light
2019-08-28 config
2019-09-05 added an s
2019-09-05 ready for production:)
2019-11-02 minor changes
2019-11-02 added Arduino code for Growlight
2020-01-29 new LED board IS3117... plus sorted out libraries
2020-03-13 files after harddrive restore
2020-03-16 added code
2020-03-26 updated with reverse polarity protection
2020-07-01 updated PCB
