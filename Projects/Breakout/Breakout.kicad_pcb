# Repository AxelGunnarson/MyKicad

## KiCad design Projects/Breakout/Breakout.kicad_pcb

Parts:
H1, H2, H3, H4: MountingHole_Pad; MountingHole_4.3mm_M4_ISO7380_Pad
J1, J2, J9, J13: DB9_Male_MountingHoles; DSUB-9_Male_Vertical_P2.77x2.84mm_MountingHoles
J3, J4, J5, J6, J7, J8, J10, J11, J12, J14, J15, J16: DB9_Female_MountingHoles; DSUB-9_Female_Vertical_P2.77x2.84mm_MountingHoles

Connections:
GND: H1.1, H2.1, H3.1, H4.1, J1.0 (PAD), J2.0 (PAD), J3.0 (PAD), J4.0 (PAD), J5.0 (PAD), J6.0 (PAD), J7.0 (PAD), J8.0 (PAD), J9.0 (PAD), J10.0 (PAD), J11.0 (PAD), J12.0 (PAD), J13.0 (PAD), J14.0 (PAD), J15.0 (PAD), J16.0 (PAD)
unnamed: J1.1, J3.1, J4.1, J5.1
unnamed: J1.2, J3.2, J4.2, J5.2
unnamed: J1.3, J3.3, J4.3, J5.3
unnamed: J1.4, J3.4, J4.4, J5.4
unnamed: J1.5, J3.5, J4.5, J5.5
unnamed: J1.6, J3.6, J4.6, J5.6
unnamed: J1.7, J3.7, J4.7, J5.7
unnamed: J1.8, J3.8, J4.8, J5.8
unnamed: J1.9, J3.9, J4.9, J5.9
unnamed: J2.1, J6.1, J7.1, J8.1
unnamed: J2.2, J6.2, J7.2, J8.2
unnamed: J2.3, J6.3, J7.3, J8.3
unnamed: J2.4, J6.4, J7.4, J8.4
unnamed: J2.5, J6.5, J7.5, J8.5
unnamed: J2.6, J6.6, J7.6, J8.6
unnamed: J2.7, J6.7, J7.7, J8.7
unnamed: J2.8, J6.8, J7.8, J8.8
unnamed: J2.9, J6.9, J7.9, J8.9
unnamed: J9.1, J10.1, J11.1, J12.1
unnamed: J9.2, J10.2, J11.2, J12.2
unnamed: J9.3, J10.3, J11.3, J12.3
unnamed: J9.4, J10.4, J11.4, J12.4
unnamed: J9.5, J10.5, J11.5, J12.5
unnamed: J9.6, J10.6, J11.6, J12.6
unnamed: J9.7, J10.7, J11.7, J12.7
unnamed: J9.8, J10.8, J11.8, J12.8
unnamed: J9.9, J10.9, J11.9, J12.9
unnamed: J13.1, J14.1, J15.1, J16.1
unnamed: J13.2, J14.2, J15.2, J16.2
unnamed: J13.3, J14.3, J15.3, J16.3
unnamed: J13.4, J14.4, J15.4, J16.4
unnamed: J13.5, J14.5, J15.5, J16.5
unnamed: J13.6, J14.6, J15.6, J16.6
unnamed: J13.7, J14.7, J15.7, J16.7
unnamed: J13.8, J14.8, J15.8, J16.8
unnamed: J13.9, J14.9, J15.9, J16.9

Board: 2 copper layers, 160.0 x 137.2 mm, 20 parts (0 on the bottom side), 37 nets.

## KiCad design Projects/Control_board/Control_board.kicad_pcb

Parts:
C1, C2, C4, C6: 0.1uF; C_0603_1608Metric
C3, C5: 1uF; C_0603_1608Metric
C7: 100nF; C_0603_1608Metric
D1, D2, D3: LED; LED_0603_1608Metric
D4, D5, D6, D7, D8, D9: BAT54SLT1G; SOT96P237X111-3N; Mouser Part Number 863-BAT54SLT1G
D10: SMF60A; D_SOD-123F; Mouser Part Number 576-SMF60A
D11: BAT54W; SOT-323_SC-70; Manufacturer_Part_Number BAT54FILMY
F1: Polyfuse; Fuse_Bourns_MF-RHT1100; Manufacturer_Part_Number 0ZRP0400FF1A
H1, H2, H3, H4: MountingHole; MountingHole_4.3mm_M4
IC1: VN7050ASTR; SOIC127P600X175-8N; Manufacturer_Part_Number VN7050ASTR; Mouser Part Number 511-VN7050ASTR
IC2: PCA9615DPJ; TSSOP-10_3x3mm_P0.5mm; Mouser Part Number 771-PCA9615DPJ
IC3: PSSI2021SAY,115; SOT65P210X100-5N; Manufacturer_Part_Number PSSI2021SAY,115; Mouser Part Number 771-PSSI2021SAY-T/R
J1: 66200621022; Mouser Part Number 710-66200621022
J2, J7: 66200621022; Manufacturer_Part_Number 66200621022; Mouser Part Number 710-66200621022
J3, J4: 43045-0200; Mouser Part Number 538-43045-0200
J5, J10: 43045-0401_2; 430450401; Mouser Part Number 538-43045-0401
J6: RJ45; RJ45_Amphenol_54602-x08_Horizontal; Manufacturer_Part_Number 54602-908LF
J8: TB003-500-P02BE; SHDR2W100P0X500_1X2_1000X780X1030P; Mouser Part Number 490-TB003-500-P02BE
J11, J12: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
J13: Conn_01x01_Female; PinHeader_1x01_P1.00mm_Horizontal
LS1: PS1240P02BT; Mouser Part Number 810-PS1240P02BT
Q1: Q_NMOS_GSD; SOT-23; Manufacturer_Part_Number DN3135K1-G
Q2: BSS138-Transistor_FET; SOT-23; Manufacturer_Part_Number BSS138A-TP
Q3, Q5: BSP76_E6433; SOT230P700X180-4N; Manufacturer_Part_Number BSP76 E6433
Q4: Q_PMOS_GDS; SOT-223-3_TabPin2; Manufacturer_Part_Number DMP6023LEQ
Q6: Q_Photo_NPN; D_1210_3225Metric_Pad1.42x2.65mm_HandSolder; Manufacturer_Part_Number 1541411NBA210; Mouser Part Number 710-1541411NBA210
R1, R8, R11, R12, R14, R20, R26, R27, R30: 1k; R_0603_1608Metric
R2, R5, R7, R13, R15, R19, R28, R29: 10K; R_0603_1608Metric
R3, R10, R16, R18: 390; R_0603_1608Metric
R4, R32, R33, R34, R35: DNP; R_0603_1608Metric
R6: 100K; R_0603_1608Metric
R9, R17, R21: 100; R_0603_1608Metric
R22: 4.7k; R_0603_1608Metric
R23: 15k; R_0603_1608Metric
R24: 39k; R_0603_1608Metric
R25: 10k; R_0603_1608Metric
R31: 100k; R_0603_1608Metric
S1, S2: FSM8JRT; Mouser Part Number 506-FSM8JRT
U1: ESP32-DEVKITC-32D; MODULE_ESP32-DEVKITC-32D; Manufacturer_Part_Number ESP32-DEVKITC-32D
U2: NCP1117-5.0_TO252; TO-252-2; Mouser Part Number 863-NCP1117DT50G
U3: NID35-12_meanwell; Converter_DCDC_MeanWell_NID30_THT; Manufacturer_Part_Number NID35-12; Mouser Part Number 709-NID35-12
Z11: BZX84C8V2LT1G; SOT95P237X111-3N; Mouser Part Number 863-BZX84C8V2LT1G

Connections:
+3V3: C4.1, D4.2, D5.2, D6.2, D7.2, D8.2, D9.2, D11.3 (K), IC2.1 (VDD(A)), J1.6, J2.6, J5.1, J6.4, J7.6, J10.1, J11.2, J12.2, LS1.1, R5.1, R6.1, R7.1, R22.1, R28.1, R29.1, R32.1
+5V: C3.2, C5.2, IC2.10 (VDD(B)), R3.1, R16.1, U1.19 (EXT_5V), U2.2 (VO)
+12V: IC1.5 (VCC_1), IC1.8 (VCC_2), J3.1, J4.1, R4.1, U2.3 (VI), U3.1 (Vout+), U3.2 (Vout+), U3.3 (Vout+), U3.4 (Vout+)
+48V: J1.4, J2.4, J7.4, Q4.3 (S), U3.7 (+Vin), U3.8 (+Vin), Z11.3 (K)
/1-Wire: IC3.5, Q1.3 (D), R25.1, U1.10 (IO26)
/12V_Fan: IC1.6 (OUTPUT_1), IC1.7 (OUTPUT_2), J1.5, J2.5, J7.5
/ADJ_LED1: J1.2, R8.1
/ADJ_LED2: J2.2, R14.1
/ADJ_LED3: J7.2, R20.1
/DSCL+: IC2.7 (DSCLP), J6.2, R16.2, R17.1
/DSCL-: IC2.6 (DSCLM), J6.1, R17.2, R18.1
/DSDA+: IC2.8 (DSDAP), J6.8, R3.2, R9.1
/DSDA-: IC2.9 (DSDAM), J6.7, R9.2, R10.1
/EN: IC2.3 (EN), U1.11 (IO27)
/LDR: R21.2, U1.33 (IO0)
/NTC_1: J1.3, R30.1
/NTC_2: J2.3, R27.2
/NTC_3: J7.3, R26.2
/SCL: IC2.4 (SCL), J11.4, J12.4, R5.2, U1.22 (IO22)
/SDA: IC2.2 (SDA), J11.3, J12.3, R7.2, U1.21 (IO23)
/Spare: R32.2, R33.1, R34.1, U1.12 (IO14)
/Touch: J13.1, U1.32 (IO4)
/airstone_pump: Q5.1 (IN), R11.1, U1.29 (IO5)
/buzzer: R2.1, U1.13 (IO12)
/fan: R1.1, R23.2, U1.9 (IO25)
/pump: Q3.1 (IN), R12.1, U1.15 (IO13)
GND: C1.2, C2.2, C3.1, C4.2, C5.1, C6.2, C7.2, D1.1 (K), D2.1 (K), D3.1 (K), D4.1, D5.1, D6.1, D7.1, D8.1, D9.1, D10.2 (A2), IC1.3 (GND), IC2.5 (VSS), IC3.3, J1.1, J2.1, J5.3, J6.5, J7.1, J8.2, J10.3, J11.1, J12.1, Q2.2 (S), Q3.3 (SOURCE), Q5.3 (SOURCE), Q6.2 (E), R10.2, R13.2, R15.2, R18.2, R19.2, R24.2, R31.2, R33.2, S1.1, S2.2, U1.14 (GND1), U1.20 (GND3), U1.26 (GND2), U2.1 (GND), U3.5 (COM), U3.6 (COM), Z11.1 (A)
unnamed: C1.1, D6.3, R8.2, U1.28 (IO18)
unnamed: C2.1, D7.3, R14.2, U1.34 (IO2)
unnamed: C6.1, D8.3, R20.2, U1.35 (IO15)
unnamed: C7.1, Q6.1 (C), R6.2, R21.1
unnamed: D1.2 (A), R11.2
unnamed: D2.2 (A), R12.2
unnamed: D3.2 (A), R1.2
unnamed: D4.3, R13.1, R26.1, U1.7 (IO32)
unnamed: D5.3, R15.1, R27.1, U1.8 (IO33)
unnamed: D9.3, R19.1, R30.2, U1.27 (IO19)
unnamed: D10.1 (A1), F1.1, Q4.2 (D)
unnamed: D11.1 (A), U1.1 (3V3)
unnamed: IC1.1 (INPUT), R23.1
unnamed: IC3.2, Q1.1 (G), R24.1
unnamed: IC3.4, R25.2
unnamed: J3.2, Q3.2 (DRAIN_1), Q3.4 (DRAIN_2)
unnamed: J4.2, Q5.2 (DRAIN_1), Q5.4 (DRAIN_2)
unnamed: J5.2, Q1.2 (S), R22.2, R35.2
unnamed: J10.2, R34.2, R35.1
unnamed: J10.4, R4.2
unnamed: LS1.2, Q2.3 (D)
unnamed: Q2.1 (G), R2.2
unnamed: Q4.1 (G), R31.1
unnamed: R28.2, S1.2, U1.6 (IO35)
unnamed: R29.2, S2.1, U1.25 (IO21)
VCC: F1.2, J8.1

Notes on the sheet:
Buzzer
1 wire interface
Max 600 mA
The board has its own voltage regulator: AMS1117-3.3
1,4 A load current MAX
700 mA
1.8 A
obsolete?
Protection circuit for 1-wire interface: https://www.maximintegrated.com/en/design/technical-documents/tutorials/5/5026.html
need heatsink/groundstitching
15-60V DC
Zener to limit Gate to Source voltage
Reverse polarity protection
15-60V DC protected side (optimized for 48V)
4A slow blow fuse
36 Euro BOM cost
This mosfet is obsolete

Board: 2 copper layers, 99.0 x 99.5 mm, 86 parts (0 on the bottom side), 53 nets.

## KiCad design Projects/DCDC/Texas_DCDC/Texas_DCDC.kicad_pcb

Parts:
C1, C2, C3, C4: 1210B225K101CT; CAPC3225X280N; Manufacturer_Part_Number 1210B225K101CT; Mouser Part Number 791-1210B225K101CT
C5: 100nF_min8V; C_0603_1608Metric
C6: 4700pF; C_0603_1608Metric
C7: 47pF; C_0603_1608Metric
C8, C9, C10: EMK325BJ226KM-P; CAPC3225X270N; Manufacturer_Part_Number EMK325BJ226KM-P; Mouser Part Number 963-EMK325BJ226KM-P
D1: B560C-13-F; DIOM7959X250N; Manufacturer_Part_Number B560C-13-F; Mouser Part Number 621-B560C-F
IC1: TPS54560BDDAR; SOIC127P600X170-9N; Manufacturer_Part_Number TPS54560BDDAR; Mouser Part Number 595-TPS54560BDDAR
L1: PA4343.133NLT; INDPM140128X650N; Manufacturer_Part_Number PA4343.133NLT; Mouser Part Number 673-PA4343.133NLT
R1: 1050k; R_0603_1608Metric
R2: 80.6k; R_0603_1608Metric
R3: 162k; R_0603_1608Metric
R4: 13k; R_0603_1608Metric
R5: 143k; R_0603_1608Metric
R6: 10.2k; R_0603_1608Metric

Connections:
/12V+: C8.1, C9.1, C10.1, L1.2, R5.1
/FB: IC1.5 (FB), R5.2, R6.1
GND: C1.2, C2.2, C3.2, C4.2, C6.2, C7.2, C8.2, C9.2, C10.2, D1.2 (A), IC1.7 (GND_1), IC1.9 (GND_2), R2.2, R3.2, R6.2
unnamed: C1.1, C2.1, C3.1, C4.1, IC1.2 (VIN), R1.1
unnamed: C5.1, D1.1 (K), IC1.8 (SW), L1.1
unnamed: C5.2, IC1.1 (BOOT)
unnamed: C6.1, R4.2
unnamed: C7.1, IC1.6 (COMP), R4.1
unnamed: IC1.3 (EN), R1.2, R2.1
unnamed: IC1.4 (RT/CLK), R3.1

Notes on the sheet:
Rhs = Rls (Vout-0.8V/0,8V)
EVM-182 Ref Des Selected component values and their minimum ratings U1 U1 TPS54360 D D1 60V Ipeak = 4.700A CIN C1-C3 4.4 µF 60V Irms = 1.930A CO C6-C7, C9 20.8 µF 12V Irms = 0.346A CBOOT C4 0.100 µF 8V LO L1 13.3 µH Isat = 4.700A Irms = 4.001A RT R3 162 kΩ RUVLO1 R1 887 kΩ RUVLO2 R2 71.5 kΩ RHS R5 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
2.2uF 100V
22uF 16V

Board: 2 copper layers, 19 parts (0 on the bottom side), 10 nets, no tracks yet.

## KiCad design Projects/LED_DRIVER_with_fan_IS31LT3117/LED_Driver_ISSI_ALU_IS31LT3117.kicad_pcb

Parts:
C1: 10u/EDK106M063A9GAA; CAPAE660X565N; Manufacturer_Part_Number EDK106M063A9GAA; Mouser Part Number 80-EDK106M063A9GAA
C2: 0.1/50V; C_0805_2012Metric
C3: 33u/VE-330M1HTR-0607; CP_Elec_6.3x7.7
C4: 1u/10V; C_1206_3216Metric
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60: LED; JK3030AWT-00-0000-000A0UJ465E
D61, D62, D63, D64, D65, D66, D67, D68: CREE_LED; CREE_XP-C_LED
H1, H2, H3, H4: MountingHole; MountingHole_4.3mm_M4
H5: throughHole; MountingHole_6.4mm_M6
IC1: IS31LT3117-ZLS4-TR; SOP65P640X120-17N; Manufacturer_Part_Number IS31LT3117-ZLS4-TR; Mouser Part Number 870-IS31LT3117-ZLS4T
J1: 43045-0809; Manufacturer_Part_Number 43045-0809; Mouser Part Number 538-43045-0809
R1: 22K; R_0805_2012Metric
R2: 6.8K; R_0805_2012Metric
R3, R4: 220; R_0805_2012Metric
TH1: Thermistor_NTC; R_0603_1608Metric

Connections:
/3.3V: J1.6, TH1.1
/48V_Fan: J1.5, R4.1
/+48V: C1.1, C2.1, C3.1, D1.2 (A), D16.2 (A), D31.2 (A), D46.2 (A), IC1.3 (VCC), J1.4, J1.8
/NTC: J1.3, TH1.2
unnamed: C4.1, IC1.9 (VREF)
unnamed: D1.1 (K), D2.2 (A)
unnamed: D2.1 (K), D3.2 (A)
unnamed: D3.1 (K), D4.2 (A)
unnamed: D4.1 (K), D5.2 (A), D62.2 (A)
unnamed: D5.1 (K), D6.2 (A), D62.1 (K)
unnamed: D6.1 (K), D7.2 (A)
unnamed: D7.1 (K), D8.2 (A)
unnamed: D8.1 (K), D9.2 (A)
unnamed: D10.1 (K), D11.2 (A), D61.2 (A)
unnamed: D9.1 (K), D10.2 (A)
unnamed: D11.1 (K), D12.2 (A), D61.1 (K)
unnamed: D12.1 (K), D13.2 (A)
unnamed: D13.1 (K), D14.2 (A)
unnamed: D14.1 (K), D15.2 (A)
unnamed: D15.1 (K), IC1.16 (VLED1)
unnamed: D16.1 (K), D17.2 (A)
unnamed: D17.1 (K), D18.2 (A)
unnamed: D18.1 (K), D19.2 (A)
unnamed: D19.1 (K), D20.2 (A), D63.2 (A)
unnamed: D20.1 (K), D21.2 (A), D63.1 (K)
unnamed: D21.1 (K), D22.2 (A)
unnamed: D22.1 (K), D23.2 (A)
unnamed: D23.1 (K), D24.2 (A)
unnamed: D24.1 (K), D25.2 (A)
unnamed: D25.1 (K), D26.2 (A), D64.2 (A)
unnamed: D26.1 (K), D27.2 (A), D64.1 (K)
unnamed: D27.1 (K), D28.2 (A)
unnamed: D28.1 (K), D29.2 (A)
unnamed: D29.1 (K), D30.2 (A)
unnamed: D30.1 (K), IC1.14 (VLED2)
unnamed: D31.1 (K), D32.2 (A)
unnamed: D32.1 (K), D33.2 (A)
unnamed: D33.1 (K), D34.2 (A)
unnamed: D34.1 (K), D35.2 (A), D65.2 (A)
unnamed: D35.1 (K), D36.2 (A), D65.1 (K)
unnamed: D36.1 (K), D37.2 (A)
unnamed: D37.1 (K), D38.2 (A)
unnamed: D38.1 (K), D39.2 (A)
unnamed: D39.1 (K), D40.2 (A)
unnamed: D40.1 (K), D41.2 (A), D66.2 (A)
unnamed: D41.1 (K), D42.2 (A), D66.1 (K)
unnamed: D42.1 (K), D43.2 (A)
unnamed: D43.1 (K), D44.2 (A)
unnamed: D44.1 (K), D45.2 (A)
unnamed: D45.1 (K), IC1.12 (VLED3)
unnamed: D46.1 (K), D47.2 (A)
unnamed: D47.1 (K), D48.2 (A)
unnamed: D48.1 (K), D49.2 (A)
unnamed: D49.1 (K), D50.2 (A), D68.2 (A)
unnamed: D50.1 (K), D51.2 (A), D68.1 (K)
unnamed: D51.1 (K), D52.2 (A)
unnamed: D52.1 (K), D53.2 (A)
unnamed: D53.1 (K), D54.2 (A)
unnamed: D54.1 (K), D55.2 (A)
unnamed: D55.1 (K), D56.2 (A), D67.2 (A)
unnamed: D56.1 (K), D57.2 (A), D67.1 (K)
unnamed: D57.1 (K), D58.2 (A)
unnamed: D58.1 (K), D59.2 (A)
unnamed: D59.1 (K), D60.2 (A)
unnamed: D60.1 (K), IC1.10 (VLED4)
unnamed: IC1.8 (ISET), R1.2, R2.2
unnamed: J1.7, R3.2
unnamed: R3.1, R4.2

Notes on the sheet:
PARALELL RESISTANCE CALCULATED FOR 340mA
resistor to lower voltage to Fan. Lowered by 2,6W/48V=54mA, 22Ohm*54mA=12V
pin 7&8 used for Fan

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